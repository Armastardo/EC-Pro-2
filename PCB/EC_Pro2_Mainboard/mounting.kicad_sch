File: PCB/EC_Pro2_Mainboard/mounting.kicad_sch (KiCad schematic)
At the start: 17 parts

Commit message: Updated sheets
Other:
- company: Cipulot PCB Design  -> LU.SV Solutions
